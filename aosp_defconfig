## arch/arm64/configs/vendor/ginkgo-perf_proton_defconfig
```kconfig
CONFIG_LLVM_POLLY=y
CONFIG_LTO_CLANG=y
CONFIG_THINLTO=y
CONFIG_LD_DEAD_CODE_DATA_ELIMINATION=y
```
